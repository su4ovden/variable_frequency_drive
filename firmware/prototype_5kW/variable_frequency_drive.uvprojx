# Keil uVision project variable_frequency_drive.uvprojx, settings and files
target Main (6160000::V6.16::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: variable_frequency_drive +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
