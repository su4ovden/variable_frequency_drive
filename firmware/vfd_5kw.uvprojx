# Keil uVision project vfd_5kw.uvprojx, settings and files
target Main (6190000::V6.19::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: vfd_5kw +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./: clock.c delay.c display.c keyboard.c main.c display_i2c.c pwm.c analog.c periphery.c control.c
  group inc
    ./: clock.h delay.h display.h keyboard.h display_i2c.h pwm.h analog.h periphery.h main.h control.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
